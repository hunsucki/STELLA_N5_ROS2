Commit message: 라이다 위치변경 + 도킹 패키지 수정

File: stella_description/urdf/stella_realsense.urdf (robot description, URDF)
Before this commit: robot stella, 6 links, 5 joints
Joints:
- joint scan2_joint: origin xyz=0.202 0.0 0.032 rpy=0.0 0.0 -1.57 -> xyz=-0.166 0.0 0.223 rpy=0.0 0.0 3.1415
